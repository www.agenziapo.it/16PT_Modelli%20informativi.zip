Properties of the parts of a building model (IFC4X3_ADD2)

# File
File name: 16_SDF_Caorso_4X3.ifc
Time: 2025-03-12T11:24:26+01:00
Written by: IfcOpenShell 0.8.2-alpha250212
Made in: Bonsai 0.8.2-alpha250212-f24de9d

# IfcBuilding, Grass
Description: Created by Civil Site Design

# IfcGeographicElement, DTM Stato di fatto
In: Stato di fatto
PredefinedType: TERRAIN
