Properties of the parts of a building model (IFC4X3_ADD2)

# File
File name: 16_SDP_MOT_Caorso_4X3 - Copia.ifc
Time: 2025-05-07T15:24:12+02:00
Written by: IfcOpenShell 0.8.3-alpha250430
Made in: Bonsai 0.8.3-alpha250430-bc221cf

# IfcBuildingElementProxy, NONE
Description: Created by Civil Site Design

# IfcGeographicElement: EMBANKMENT, Deposito scotico
In: Diaframmatura Caorso
PredefinedType: USERDEFINED
Identificazione - Codifica: MOT; Codifica_specifica: E; ID_Locale/Zona: A; ID_Oggetto: 002; ID_Scheda: 16
Anagrafica - WBS: S16.A.MOT.002.E

# IfcGeographicElement: SUBGRADE, Pista di cantiere
In: Diaframmatura Caorso
PredefinedType: USERDEFINED
Identificazione - Codifica: MOT; Codifica_specifica: S; ID_Locale/Zona: A; ID_Oggetto: 001; ID_Scheda: 16
Anagrafica - WBS: S16.A.MOT.001.S
